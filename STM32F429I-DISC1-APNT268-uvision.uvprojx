# Keil uVision project STM32F429I-DISC1-APNT268-uvision.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429I-DISC1-APNT268-uvision
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HSE_VALUE=8000000 USE_STM32F429I_DISCO_REVD
  c include: .\;.\ili9341
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: retarget_stdio.c Blinky.c stm32f429i_discovery.c LCD_X.c GUI_SingleThread.c LogViewerDLG.c Touch_STMPE811.c
    ./ili9341/: ili9341.c
  group :CubeMX:CubeMX
    ./STM32CubeMX/Target_1/STM32CubeMX/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c system_stm32f4xx.c stm32f4xx_hal_timebase_tim.c
    ./STM32CubeMX/Target_1/STM32CubeMX/MDK-ARM/: startup_stm32f429xx.s
  group :CubeMX:STM32 HAL Driver
    ./STM32CubeMX/Target_1/STM32CubeMX/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma2d.c stm32f4xx_ll_fmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c stm32f4xx_hal_sdram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDERR:Custom 1.1.0, CMSIS-Compiler:STDIN:Custom 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.1.1, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, CMSIS Driver:GPIO 1.2.0, CMSIS Driver:I2C 3.0.0, CMSIS Driver:USART 3.0.0, CMSIS Driver:VIO:Board 1.0.0, Device:CubeMX 1.0.0, Graphics:CORE 6.32.3, Graphics:Display:Interface Template 6.32.3, Graphics:Input Device:Touchscreen 6.32.3, Graphics:Tools:GUI Builder 6.32.3
